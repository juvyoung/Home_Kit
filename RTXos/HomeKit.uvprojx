# Keil uVision project HomeKit.uvprojx, settings and files
target HomeKit_juv (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HomeKit_rtos +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__CORTEX_M4 __FPU_PRESENT=1 __CMSIS_RTOS
  c include: .\_cfg;.\_GPIO;.\_LED;.\_RTX_HAL;.\_RTX_inc;.\_RTX_Kernel;.\_CMSIS\Include;.\_CMSIS;.\_STM32F4xx_StdPeriph_Driver\inc;.\_STM32F4xx_StdPeriph_Driver\src;.\_User
  asm define: __CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./_Startup/: startup_stm32f407xx.s
  group GPIO
    ./_GPIO/: Gpio.c Gpio.h
  group User
    ./_User/: main.c osObjects.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group cfg
    ./_cfg/: types.h
  group LED
    ./_LED/: LED.c LED.h
  group STM32F4xx_StdPeriph_Driver
    ./_STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
    ./_STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_gpio.h stm32f4xx_rcc.h
  group CMSIS
    ./_CMSIS/: RTX_Conf_CM.c system_stm32f4xx.c system_stm32f4xx.h
  group RTX_HAL
    ./_RTX_HAL/: HAL_CM.c HAL_CM4.c rt_HAL_CM.h rt_TypeDef.h RTX_Config.h SVC_Table.s
  group RTX_inc
    ./_RTX_inc/: cmsis_os.h RTX_CM_lib.h
  group RTX_Kernel
    ./_RTX_Kernel/: rt_CMSIS.c rt_Event.c rt_Event.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h
